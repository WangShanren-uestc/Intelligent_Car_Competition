# IAR project FIRE_KL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL26Z256xxx4 Freescale MKL26Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; MKL26Z4; ARM_MATH_CM0PLUS
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\SD_CARD
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FIRE_KL.hex
  ILINK.IlinkOutputFile: FIRE_KL.out
  ILINK.IlinkIcfFile: config files\256KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; MKL26Z4; ARM_MATH_CM0PLUS
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc
  ICCARM.CCOptLevel: 3
  group App
    ../../App/: darw.c image_2.c main.c MKL_it.c moto.c motofix.c motoII.c oled.c test.c test.h tool.c
  group Board
    ../../Board/Src/: FIRE_ASCII.c FIRE_camera.c FIRE_key.c FIRE_key_event.c FIRE_LCD.c FIRE_LCD_CH.c FIRE_LCD_ST7735R.c FIRE_LCD_ST7735S.c FIRE_LED.C FIRE_MKL_conf.c FIRE_MMA7455.c FIRE_NRF24L0.c FIRE_NRF24L0_MSG.c FIRE_OV7725_Eagle.c FIRE_SCCB.c FIRE_TSL1401.c FIRE_UI_VAR.c
  group Chip
    ../../Chip/Src/: misc.c MKL_adc.c MKL_dac.c MKL_dma.c MKL_flash.c MKL_gpio.c MKL_i2c.c MKL_lptmr.c MKL_mcg.c MKL_PIT.c MKL_port.c MKL_spi.c MKL_SysTick.c MKL_TPM.c MKL_uart.c MKL_wdog.c
    ../../Chip/Src/IAR/: startup_MKL.s system_MKL.c vectors.c
  group LIB/CMSIS
    ../../Lib/CMSIS/: iar_cortexM0plusl_math.a
